# Keil uVision project GPIO driver development II.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GPIO driver development II
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group GPIO
    ./: gpio_driver.c gpio_api.c gpio_api.h gpio_driver.h gpio_structures_and_defines.h
  group SysTick
    ./: systick_delay.c systick_delay.h
  group LCD
    ./: rg1602A_driver.c rg1602A_driver.h
  group __4x4-keypad
    ./: keypad_driver.h keypad_driver.c
  group digitalClock-main
    ./: main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
